# Repository ryood/MIX0401

## EAGLE design eagle/MIX0401/MIX0401_Main.brd

Parts:
C1, C2, C3, C4: 10uF; E2,5-5
C5, C6, C8, C9: 0.1uF; C025-024X044
C7: 22pF; C050-024X044
C10, C11: 100uF; E2,5-7
C12, C13: 47uF; E2,5-6
IC1, IC2: NJM4580; DIL08
JP1: OUT; 1X02
JP2: MASTER_LEVEL; 1X02
JP3: IN; 1X05
JP4: PWRIN; 1X02
JP5: TP_GND; 1X02
JP6: LED; 1X02
R1, R2, R3, R4: 10k; 0207/7
R5: 33k; 0207/7
R6: 2.2k; 0207/7
R7: 560; 0207/7
R8, R9, R10: 100k; 0207/7
R11: 1k; 0207/7
R12: 100; 0207/7

Connections:
GND: C6.1, C9.1, C11.-, C13.-, IC1.4 (V-), IC2.4 (V-), JP1.2, JP3.5, JP4.2, JP5.1, JP5.2, JP6.2, R8.1, R10.1
unnamed: C7.1, IC1.2 (-IN), R1.2, R2.2, R3.2, R4.2, R5.1
unnamed: C1.-, JP3.1
unnamed: IC1.3 (+IN), R6.2
unnamed: IC2.2 (-IN), JP2.1, R7.2
unnamed: C1.+, R1.1
unnamed: C7.2, IC1.1 (OUT), R5.2, R7.1
unnamed: C2.+, R2.1
unnamed: C3.+, R3.1
unnamed: C4.+, R4.1
unnamed: C10.-, JP1.1, R8.2
unnamed: IC1.5 (+IN), R9.1, R10.2
unnamed: IC2.6 (-IN), IC2.7 (OUT), R12.2
unnamed: IC2.1 (OUT), IC2.5 (+IN), JP2.2
unnamed: C2.-, JP3.2
unnamed: C3.-, JP3.3
unnamed: C4.-, JP3.4
unnamed: JP6.1, R11.1
unnamed: C10.+, R12.1
VCC: C5.1, C8.1, C11.+, C12.+, IC1.8 (V+), IC2.8 (V+), JP4.1, R9.2, R11.2
VCC/2: C5.2, C6.2, C8.2, C9.2, C12.-, C13.+, IC1.6 (-IN), IC1.7 (OUT), IC2.3 (+IN), R6.1

Notes on the sheet:
PWR
Buffer
Summing
Amp
Rail Splitter
PinSocketで実装

Board: 2 copper layers, 71.2 x 45.7 mm, 33 parts (0 on the bottom side), 21 nets.

## Commit log

2018-03-27 before for test
2018-04-01 Add: fritzing files
2018-04-02 Use Virtual-GND in spice of MIX0401
2018-04-04 Add: Eagle files
2018-04-07 Update: Eagle files
2018-04-12 はんだ付け完了
2018-04-22 Update: case design
2018-04-24 Update: ケース内配線
